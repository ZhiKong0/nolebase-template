# Keil uVision project ICM42688_IMU.uvprojx, settings and files
target ICM42688_IMU (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ICM-20602-IMU +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\IIC;..\HARDWARE\IMU;..\HARDWARE\EEPROM;..\HARDWARE\SPI;..\HARDWARE\ICM42688;..\HARDWARE\MOTOR_CONTROL;..\HARDWARE\APP_UTIL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/IMU/: IMU.c
    ../HARDWARE/APP_UTIL/: VOFA.c Key.c Encoder.c
    ../HARDWARE/MOTOR_CONTROL/: PWM.c Motor.c PID.c Control.c
    ../HARDWARE/ICM42688/: icm42688.c
    ../HARDWARE/SPI/: spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_spi.c
software components: CMSIS:CORE 5.4.0
