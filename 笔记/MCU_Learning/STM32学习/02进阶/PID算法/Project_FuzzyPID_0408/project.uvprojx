# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Start;.\System;.\User;.\Library;.\Hardware;.\Bsp;.\Drivers;.\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h sys.c sys.h usart.c usart.h
  group Hardware
    ./Hardware/: OLED.c OLED_Font.c OLED.h OLED_Font.h VOFA.c VOFA.h SoftSerial.c SoftSerial.h
  group Bsp
    ./Bsp/: BoardConfig.h BspControlTick.c BspControlTick.h BspFaultTrace.c BspFaultTrace.h
  group Drivers
    ./Drivers/: DrvDisplay.c DrvDisplay.h DrvTelemetry.c DrvTelemetry.h DrvKey.c DrvKey.h DrvMotor.c DrvMotor.h DrvEncoder.c DrvEncoder.h DrvTrackSensor.c DrvTrackSensor.h DrvImuBno08x.c DrvImuBno08x.h DrvParamStore.c DrvParamStore.h
  group App
    ./App/: AppTypes.h AppPid.c AppPid.h AppFuzzy.c AppFuzzy.h AppLearning.c AppLearning.h AppPerformance.c AppPerformance.h AppProtocol.c AppProtocol.h AppConfigProfile.c AppConfigProfile.h AppRuntime.h AppMotionSupervisor.c AppMotionSupervisor.h AppTelemetryService.c AppTelemetryService.h AppUiService.c AppUiService.h AppCommandDispatcher.c AppCommandDispatcher.h AppModeManager.c AppModeManager.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
